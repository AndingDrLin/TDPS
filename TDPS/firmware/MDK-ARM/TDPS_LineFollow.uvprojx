# Keil uVision project TDPS_LineFollow.uvprojx, settings and files
target TDPS_LineFollow (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: TDPS_LineFollow +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,LF_USE_STM32F4_HAL_PORT,WL_USE_STM32F4_HAL_PORT
  c include: ../Core/Inc;../Inc;../platform;../common;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/Core
    ../Src/: main.c
    ../Core/Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c system_stm32f4xx.c
  group Application/LineFollow
    ../Src/: lf_app.c lf_chassis.c lf_config.c lf_config_profiles.c lf_control.c lf_debug_monitor.c lf_dgus_screen.c lf_future_hooks.c lf_led_blink.c lf_platform_stm32f4_hal.c lf_radar.c lf_radar_uart.c lf_run_log.c lf_sensor.c lf_sensor_uart.c tdps_uart_callbacks.c
  group Application/Wireless
    ../Src/: wireless_hooks.c wl_app.c wl_config.c wl_lora.c wl_platform_stm32f4.c wl_protocol.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
software components: CMSIS:CORE 4.3.0
